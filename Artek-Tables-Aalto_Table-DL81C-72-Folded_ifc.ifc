Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-12-06T14:34:24
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20191106_1200(x64) - Exporter 20.2.1.1 - Alternate UI 20.2.1.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Dec 06 14:34:24 2023 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\0690d289-da47-4a7a-8c21-f175941aff09\cabec7f1-dae5-4091-8fec-2272a0c27c1e\ifc * Database version: 5507 * Database creation date: Wed Dec 06 14:34:23 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Dec 06 14:34:23 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Dec 06 14:34:23 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFurnishingElement: Aalto Table, DL81C, 720 mm, Artek-Tables-Aalto_Table-DL81C_rfa:Aalto Table, DL81C, 720 mm:349608
In: Level 1
Type - Material: Natural laquered, Black laquered, Stainless Steel
Type - Constraints - Default Elevation: 0 mm
Type - Construction - TableType: Table DL81C_720
Type - General - Author: BIMstone; BIMObjectName: Artek-Tables-Aalto_Table-DL81C_rfa; ManufacturerName: Artek; ManufacturerURL: https://www.artek.fi/; NBSDescription: Tables; NBSReference: 45-35-86/327; ProductInformation: The Aalto Table conveys a relaxed familiarity that resists categorisation. Whether used for dining, working, or playing, the table retains its character while offering endless possibilities.; Revision: n/a; Uniclass2: Pr_40_50_21_21; Uniclass2015Description: Dining tables; Uniclass2015Reference: Pr_40_50_21_22; Version: 1; VersionDate: 05/12/2023
Type - Identity Data - Collection: Aalto; Cost: 0; Description: The Aalto Table conveys a relaxed familiarity that resists categorisation. Whether used for dining, working, or playing, the table retains its character while offering endless possibilities.; Designer: Alvar Aalto, 1935; Manufacturer: Artek; Model: Aalto Table, DL81C, 720 mm; OmniClass Number: 23.40.20.14.17.11; OmniClass Title: Dining Room Tables; Type Name: Aalto Table, DL81C, 720 mm; URL: https://www.studiopazo.ca/collections/artek/products/aalto-table-table-dl81c-folding-table
Type - Other - Category: Furniture; AccessibilityPerformance: n/a; AssetType: Movable; Brand: Artek; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: Artek-Tables-Aalto_Table-DL81C_rfa; Features: Folding table; Finish: The Finnish birch from which Aalto tables are made boasts a natural beauty and radiates warmth; Grade: n/a; Material: Wood and laminate; ModelNumber: n/a; ModelReference: n/a; Name: Aalto_Table-DL81C; ReplacementCost: n/a; Shape: Sculptured; Size: 750 +(40 : 380) x 750 x 720 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Various
Type - Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: Artek
Type - Pset_ProductRequirements - Name: Aalto_Table-DL81C; Category: Furniture
Type - Pset_QuantityTakeOff - Reference: Aalto Table, DL81C, 720 mm
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Constraints - Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset from Host: 0 mm
Construction - FoldVisibility: yes
Dimensions - Area: 3.90034 m2; Volume: 0.427457 m3
Materials and Finishes - TableMainMaterial: Natural laquered; TableSecondaryMaterial: Black laquered
Other - AssetIdentifier: n/a; Barcode: n/a; Family: Artek-Tables-Aalto_Table-DL81C_rfa: Aalto Table, DL81C, 720 mm; Family and Type: Artek-Tables-Aalto_Table-DL81C_rfa: Aalto Table, DL81C, 720 mm; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: Artek-Tables-Aalto_Table-DL81C_rfa: Aalto Table, DL81C, 720 mm; Type Id: Artek-Tables-Aalto_Table-DL81C_rfa: Aalto Table, DL81C, 720 mm; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
